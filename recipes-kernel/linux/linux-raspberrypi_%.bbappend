FILESEXTRAPATHS:prepend := "${THISDIR}/linux-raspberrypi:"
SRC_URI:append = " file://rpi5-4k-pages.cfg"
